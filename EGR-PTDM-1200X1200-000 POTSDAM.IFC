Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Potsdam\EGR-PTDM-1200X1200-000 POTSDAM.IFC
Time: 2024-11-28T11:37:56+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 21.5545560982298596; Volume Measure: 0.0215545560982299; Area Measure: 4.2208099518256645

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 21.5545560982298596; Volume Measure: 0.0215545560982299; Area Measure: 4.2208099518256645

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 21.5545560982298596; Volume Measure: 0.0215545560982299; Area Measure: 4.2208099518256645

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGR-PTDM-1200X1200-000 POTSDAM | PSet_Mass_Property - Mass Measure: 21.5545560982298596; Volume Measure: 0.0215545560982299; Area Measure: 4.2208099518256645
EGR-PTDM-1200X1200-000 POTSDAM

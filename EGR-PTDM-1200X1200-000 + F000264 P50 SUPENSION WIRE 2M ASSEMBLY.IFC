Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Potsdam\EGR-PTDM-1200X1200-000 + F000264 P50 SUPENSION WIRE 2M ASSEMBLY.IFC
Time: 2024-11-28T11:39:18+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 21.8195165243008447; Volume Measure: 0.0218195165243009; Area Measure: 4.4904084868647010

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 21.8195165243008447; Volume Measure: 0.0218195165243009; Area Measure: 4.4904084868647010

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 21.8195165243008447; Volume Measure: 0.0218195165243009; Area Measure: 4.4904084868647010

# IfcBuildingElementProxy (26)
In: default BuildingStorey
Name
EGR-PTDM-1200X1200-000 + F000264 P50 SUPENSION WIRE 2M ASSEMBLY | PSet_Mass_Property - Mass Measure: 21.8195165243008447; Volume Measure: 0.0218195165243009; Area Measure: 4.4904084868647010
F000264 P50 SUSPENSION FITTING.SLDPRT
4 x F000264 P50 Top Threaded Insert
4 x F000264 P50 M5 Threaded Bolt
4 x F000264 P50 Clutch Fitting
4 x F000264 P50 Tensile Steel Wire 2m
H Section Hanging Extrusion
H Section Hanging Extrusion-1
F000264 P50 SUSPENSION FITTING.SLDPRT-1
H Section Hanging Extrusion-2
EGR-PTDM-1200X1200-000 POTSDAM
F000264 P50 SUSPENSION FITTING.SLDPRT-2
H Section Hanging Extrusion-3
F000264 P50 SUSPENSION FITTING.SLDPRT-3

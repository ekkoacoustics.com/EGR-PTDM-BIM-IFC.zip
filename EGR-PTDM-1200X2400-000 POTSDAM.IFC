Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Potsdam\EGR-PTDM-1200X2400-000 POTSDAM.IFC
Time: 2024-11-28T12:05:30+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 46.5782688058331047; Volume Measure: 0.0465782688058331; Area Measure: 8.9937488460178105

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 46.5782688058331047; Volume Measure: 0.0465782688058331; Area Measure: 8.9937488460178105

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 46.5782688058331047; Volume Measure: 0.0465782688058331; Area Measure: 8.9937488460178105

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
EGR-PTDM-1200X2400-000 POTSDAM | PSet_Mass_Property - Mass Measure: 46.5782688058331047; Volume Measure: 0.0465782688058331; Area Measure: 8.9937488460178105
EGR-PTDM-1200X2400-000 POTSDAM

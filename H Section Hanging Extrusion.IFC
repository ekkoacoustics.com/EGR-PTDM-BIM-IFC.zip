Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Potsdam\H Section Hanging Extrusion.IFC
Time: 2024-11-28T12:08:26+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 0.0614966567294915; Volume Measure: 0.0000614966567295; Area Measure: 0.0612022162761771

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 0.0614966567294915; Volume Measure: 0.0000614966567295; Area Measure: 0.0612022162761771

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 0.0614966567294915; Volume Measure: 0.0000614966567295; Area Measure: 0.0612022162761771

# IfcBuildingElementProxy (2)
In: default BuildingStorey
Name
H Section Hanging Extrusion | PSet_Mass_Property - Mass Measure: 0.0614966567294915; Volume Measure: 0.0000614966567295; Area Measure: 0.0612022162761771
H Section Hanging Extrusion

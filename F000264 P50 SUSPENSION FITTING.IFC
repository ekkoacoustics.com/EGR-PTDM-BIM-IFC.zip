Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Potsdam\F000264 P50 SUSPENSION FITTING.IFC
Time: 2024-11-28T12:09:13+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 0.0047434497882558; Volume Measure: 0.0000047434497883; Area Measure: 0.0061974174835827

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 0.0047434497882558; Volume Measure: 0.0000047434497883; Area Measure: 0.0061974174835827

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 0.0047434497882558; Volume Measure: 0.0000047434497883; Area Measure: 0.0061974174835827

# IfcBuildingElementProxy (5)
In: default BuildingStorey
Name
F000264 P50 SUSPENSION FITTING.SLDPRT | PSet_Mass_Property - Mass Measure: 0.0047434497882558; Volume Measure: 0.0000047434497883; Area Measure: 0.0061974174835827
F000264 P50 Top Threaded Insert
F000264 P50 M5 Threaded Bolt
F000264 P50 Clutch Fitting
F000264 P50 Tensile Steel Wire 2m

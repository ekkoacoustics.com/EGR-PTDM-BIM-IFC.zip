Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition[ReferenceView]
File name: C:\Users\cmdes\OneDrive\Clients\Mode\Solidworks\Potsdam\EGR-PTDM-1200X2400-000 + F000264 P50 SUPENSION WIRE 2M ASSEMBLY.IFC
Time: 2024-11-28T12:07:23+00:00
Written by: 3DEXPERIENCE PlatformUnofficial Packaging Version
Made in: 3DEXPERIENCE Platform IFC4

# IfcProject, Project
Description: Default Project

# IfcSite, default Site
PSet_Mass_Property - Mass Measure: 47.1081896579750605; Volume Measure: 0.0471081896579751; Area Measure: 9.5329459160958852

# IfcBuilding, default Building
PSet_Mass_Property - Mass Measure: 47.1081896579750605; Volume Measure: 0.0471081896579751; Area Measure: 9.5329459160958852

# IfcBuildingStorey, default BuildingStorey
In: default Building
PSet_Mass_Property - Mass Measure: 47.1081896579750605; Volume Measure: 0.0471081896579751; Area Measure: 9.5329459160958852

# IfcBuildingElementProxy (50)
In: default BuildingStorey
Name
EGR-PTDM-1200X2400-000 + F000264 P50 SUPENSION WIRE 2M ASSEMBLY | PSet_Mass_Property - Mass Measure: 47.1081896579750605; Volume Measure: 0.0471081896579751; Area Measure: 9.5329459160958852
H Section Hanging Extrusion
H Section Hanging Extrusion-1
F000264 P50 SUSPENSION FITTING.SLDPRT
8 x F000264 P50 Top Threaded Insert
8 x F000264 P50 M5 Threaded Bolt
8 x F000264 P50 Clutch Fitting
8 x F000264 P50 Tensile Steel Wire 2m
F000264 P50 SUSPENSION FITTING.SLDPRT-1
F000264 P50 SUSPENSION FITTING.SLDPRT-2
F000264 P50 SUSPENSION FITTING.SLDPRT-3
F000264 P50 SUSPENSION FITTING.SLDPRT-4
H Section Hanging Extrusion-2
H Section Hanging Extrusion-3
F000264 P50 SUSPENSION FITTING.SLDPRT-5
F000264 P50 SUSPENSION FITTING.SLDPRT-6
H Section Hanging Extrusion-4
EGR-PTDM-1200X2400-000 POTSDAM
H Section Hanging Extrusion-5
H Section Hanging Extrusion-6
F000264 P50 SUSPENSION FITTING.SLDPRT-7
H Section Hanging Extrusion-7
